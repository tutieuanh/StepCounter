# Keil uVision project StepCounter.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: StepCounter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application
    ./: main.c
  group Library
    ./: SysTick.h SysTick.c Timer.h Timer.c LCD1602.h LCD1602.c MPU6050.h MPU6050.c I2C.h I2C.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
